# Keil uVision project new_project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: new_project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F103xE,USE_HAL_DRIVER
  c include: ..\3_Drivers\4_CMSIS\Device\ST\STM32F1xx\Include;..\3_Drivers\4_CMSIS\Include;..\3_Drivers\3_HAL\Inc;..\3_Drivers\1_BSP;..\3_Drivers;..\1_User;..\3_Drivers\2_SYSTEM
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../3_Drivers/4_CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
    ../3_Drivers/4_CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group User
    ../1_User/: main.c stm32f1xx_it.c
  group Drivers/BSP
    ../3_Drivers/1_BSP/led/: led.c
    ../3_Drivers/1_BSP/exti/: exti.c
    ../3_Drivers/1_BSP/iwdg/: iwdg.c
    ../3_Drivers/1_BSP/wwdg/: wwdg.c
    ../3_Drivers/1_BSP/tim/: tim.c
  group Drivers/SYSTEM
    ../3_Drivers/2_SYSTEM/delay/: delay.c
    ../3_Drivers/2_SYSTEM/sys/: sys.c
    ../3_Drivers/2_SYSTEM/usart/: usart.c
  group Drivers/HAL
    ../3_Drivers/3_HAL/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_wwdg.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
